# Keil uVision project OLED_GIF_Demo.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: OLED_GIF_Demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Hardware;..;..\..\06_LED_OLED\Start;..\..\06_LED_OLED\Library;..\..\06_LED_OLED\System
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../../06_LED_OLED/Start/: startup_stm32f10x_md.s system_stm32f10x.c stm32f10x.h system_stm32f10x.h core_cm3.h
  group SPL
    ../../06_LED_OLED/Library/: stm32f10x_gpio.c stm32f10x_rcc.c
  group System
    ../../06_LED_OLED/System/: Delay.c Delay.h
  group Hardware
    ./Hardware/: OLED.c OLED.h
  group Animation
    ../: GifFrames.c GifFrames.h
  group User
    ./User/: main.c stm32f10x_conf.h
